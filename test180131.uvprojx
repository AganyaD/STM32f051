# Keil uVision project test180131.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test180131
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS\Device\ST\STM32F0xx\Source\Templates;.\STM32F0xx_StdPeriph_Driver;.\STM32F0xx_StdPeriph_Driver\inc;.\STM32F0xx_StdPeriph_Driver\src;.\User;..\;.\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ./: startup_stm32f072.s
  group User
    ./: main.c
  group CMSIS
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group StdPeriph
    ./STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c
  group hal
    ./STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_msp_template.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_timebase_rtc_alarm_template.c stm32f0xx_hal_timebase_rtc_wakeup_template.c stm32f0xx_hal_timebase_tim_template.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_adc.c stm32f0xx_ll_comp.c stm32f0xx_ll_crc.c stm32f0xx_ll_crs.c stm32f0xx_ll_dac.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_i2c.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_rtc.c stm32f0xx_ll_spi.c stm32f0xx_ll_tim.c stm32f0xx_ll_usart.c stm32f0xx_ll_utils.c
